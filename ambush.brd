# Repository granthaack/ambush_ttl

## EAGLE design ambush.brd

Parts:
C4, C12, C13, C21, C25, C26, C31, C32, C34, C35, C38, C39: 100nF; C025-040X050
C5, C16, C18, C19, C20, C22, C24, C27, C28, C30, C36, C37: 10nF; C025-040X050
C6: 100uF; E2,5-7
C17: 10uF; E2,5-7
C23: 1uF; E2,5-7
C29: 47nF; C025-040X050
C33: 200nF; C025-040X050
DIS1, DIS2, DIS3, DIS4: HD-F103; HDSP-E
IC2, IC5, IC28, IC37, IC39, IC54: 7404N; DIL14
IC4, IC22, IC23, IC25, IC26, IC29, IC34, IC35, IC52: LM555N; DIL08
IC6, IC9, IC14, IC15: 74LS93N; DIL14
IC11, IC53: 7430N; DIL14
IC12, IC21, IC24, IC30, IC38, IC50: 7400N; DIL14
IC13: LM386N-3; DIL08
IC16: 7410N; DIL14
IC17, IC18, IC36: 7402N; DIL14
IC19: 7486N; DIL14
IC20: 74125N; DIL14
IC27: 74S20N; DIL14
IC31: 7475N; DIL16
IC32, IC33: 7485N; DIL16
IC40, IC41, IC45, IC46, IC47: 7490N; DIL14
IC42, IC43, IC48, IC49: 4511N; DIL16
IC44: 74LS92N; DIL14
IC51: 74116N; DIL24-6
MOV_POT: 500k; 3RP/1610N
R3: 4.7k; 0207/10
R4: 100k; 0207/10
R5, R6, R7, R8, R9: 15k; 0207/10
R10, R17, R26: 330; 0207/10
R18, R21, R22, R23, R24, R25, R27: 2.2k; 0207/10
R28, R32, R33: 22k; 0207/10
R29, R31, R38, R39, R41, R44, R45, R54, R55, R57: 470; 0207/10
R30: 2.73M; 0207/10
R34: 1.5M; 0207/10
R35, R37, R42, R43, R56: 1M; 0207/10
R36: 470k; 0207/10
R40: 3.3k; 0207/10
R46, R47, R48, R49, R50, R51, R52, R53, R58: 10k; 0207/10
SP1: KSS1201
T1, T2, T3, T4, T5, T6: 2N3904; TO92
V1, V3: 74112N; DIL16
V2, V4: 7474N; DIL14
Y1: 14.3 MHz; HC49US

Connections:
1H: IC6.1 (CKB), IC6.12 (QA)
1HZ: IC45.11 (QD), IC46.1 (CKB), R50.1
1V: IC14.1 (CKB), IC14.12 (QA), IC16.13 (I2), IC31.2 (D1)
2H: IC6.9 (QB), IC11.12 (I7)
2V: IC14.9 (QB), IC31.3 (D2)
4H: IC6.8 (QC), IC11.11 (I6)
4V: IC14.8 (QC), IC16.2 (I1), IC16.5 (I2), IC31.6 (D3)
8H: IC6.11 (QD), IC9.14 (CKA)
8V: IC14.11 (QD), IC15.14 (CKA), IC17.8 (I0), IC17.9 (I1), IC31.7 (D4)
16H: IC9.1 (CKB), IC9.12 (QA), IC12.2 (I1), IC33.9 (B0)
16V: IC15.1 (CKB), IC15.12 (QA), IC17.6 (I1), IC32.9 (B0)
32H: IC9.9 (QB), IC12.12 (I0), IC33.11 (B1), IC37.5 (I)
32V: IC15.9 (QB), IC32.11 (B1)
64H: IC9.8 (QC), IC11.6 (I5), IC12.1 (I0), IC33.14 (B2), IC37.3 (I)
64V: IC15.8 (QC), IC32.14 (B2)
128H: IC9.11 (QD), IC11.5 (I4), IC33.1 (B3), IC37.1 (I), V1.13 (CLK)
128V: IC15.11 (QD), IC32.1 (B3), V3.1 (CLK)
256H: IC11.4 (I3), IC28.13 (I), V1.9 (Q)
256V: IC16.1 (I0), V3.5 (Q)
!32H: IC27.5 (I3), IC37.6 (O)
!64H: IC27.4 (I2), IC37.4 (O)
!128H: IC27.2 (I1), IC37.2 (O)
!256H: IC27.1 (I0), IC28.12 (O)
!BDEAD: IC37.12 (O), IC38.1 (I0)
!BG_FLASH: IC39.12 (O), IC51.8 (D3), IC53.12 (I7)
!GDEAD: IC22.4 (R), IC37.8 (O), IC51.16 (D1), IC53.4 (I3)
!GFIRE: C19.2, IC51.6 (D2), IC53.6 (I5), R33.1
!GH: IC24.12 (I0), IC28.2 (O), IC36.2 (I0)
!GHIT: IC30.8 (O), IC39.1 (I)
!GV: IC28.4 (O), IC28.5 (I), IC30.1 (I0), IC36.3 (I1)
!HRST: IC12.10 (I1), V1.14 (!CLR), V2.5 (Q)
!LOAD: IC51.10 (D4), IC53.11 (I6), IC54.2 (O)
!SOUND_EN: IC39.10 (O), IC51.2 (G1), IC51.3 (G2), IC51.14 (G1), IC51.15 (G2)
!START: IC21.2 (I1), IC38.4 (I0), IC51.4 (D1), IC53.5 (I4), R28.1
!STOP: IC38.10 (I1), IC39.8 (O), IC50.4 (I0)
!VRST: IC29.2 (TR), IC37.10 (O)
+5V: IC4.4 (R), IC4.8 (V+), IC13.6 (VS), IC19.5 (I1), IC22.8 (V+), IC23.8 (V+), IC25.4 (R), IC25.8 (V+), IC26.8 (V+), IC29.8 (V+), IC34.4 (R), IC34.8 (V+), IC35.4 (R), IC35.8 (V+), IC42.3 (LT), IC42.4 (BI), IC43.3 (LT), IC43.4 (BI), IC48.3 (LT), IC48.4 (BI), IC49.3 (LT), IC49.4 (BI), IC52.4 (R), IC52.8 (V+), IC53.1 (I0), IC53.2 (I1), IC53.3 (I2), MOV_POT.2 (S), R3.2, R18.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.1, R28.2, R30.1, R32.2, R33.2, R34.1, R35.1, R37.1, R42.2, R43.2, R44.1, R45.1, R56.2, R57.2
+UB: V1.16 (+UB), V2.14 (+UB), V3.16 (+UB), V4.14 (+UB)
-UB: V1.8 (-UB), V2.7 (-UB), V3.8 (-UB), V4.7 (-UB)
AST_TRG: C4.1, IC4.2 (TR), IC4.6 (THR), T1.3 (E), T2.3 (E), T3.3 (E), T4.3 (E), T5.3 (E), T6.3 (E)
BDEAD: IC24.4 (I0), IC25.3 (Q), IC26.4 (R), IC37.13 (I)
BG_FLASH: IC26.3 (Q), IC36.5 (I0), IC39.13 (I)
CVID: IC20.3 (O), R26.2, R27.1
GAMEACTIVE: IC21.13 (I1), IC22.3 (Q), IC29.4 (R)
GAME_VID: IC18.2 (I0), IC18.3 (I1), IC28.10 (O)
GND: C4.2, C5.1, C16.2, C17.-, C20.2, C21.2, C22.2, C23.-, C24.2, C25.2, C28.2, C29.2, C31.1, C32.1, C33.1, C34.1, C38.1, C39.2, DIS1.1 (CC), DIS1.6 (CC), DIS1.7 (DP), DIS2.1 (CC), DIS2.6 (CC), DIS2.7 (DP), DIS3.1 (CC), DIS3.6 (CC), DIS3.7 (DP), DIS4.1 (CC), DIS4.6 (CC), DIS4.7 (DP), IC2.7 (GND), IC4.1 (GND), IC5.5 (I), IC5.6 (O), IC5.7 (GND), IC5.8 (O), IC5.9 (I), IC5.10 (O), IC5.11 (I), IC5.12 (O), IC5.13 (I), IC6.10 (GND), IC9.10 (GND), IC11.7 (GND), IC12.7 (GND), IC13.2 (-IN), IC13.4 (GND), IC14.10 (GND), IC15.10 (GND), IC16.7 (GND), IC17.7 (GND), IC18.7 (GND), IC19.7 (GND), IC20.7 (GND), IC21.7 (GND), IC22.1 (GND), IC23.1 (GND), IC24.7 (GND), IC25.1 (GND), IC26.1 (GND), IC27.7 (GND), IC28.7 (GND), IC29.1 (GND), IC30.7 (GND), IC31.12 (GND), IC32.2 (A<B_I), IC32.4 (A>B_I), IC32.8 (GND), IC33.2 (A<B_I), IC33.4 (A>B_I), IC33.8 (GND), IC33.15 (A3), IC34.1 (GND), IC35.1 (GND), IC36.7 (GND), IC37.7 (GND), IC38.7 (GND), IC39.7 (GND), IC40.6 (R9(1)), IC40.7 (R9(2))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
GV=BV: IC24.2 (I1), IC28.8 (O), IC30.9 (I0)
HBLANK: IC17.12 (I1)
HCLK: IC6.14 (CKA), V1.5 (Q), V2.3 (CLK)
HRST: IC6.2 (R0(1)), IC6.3 (R0(2)), IC9.2 (R0(1)), IC9.3 (R0(2)), IC14.14 (CKA), V2.6 (!Q), V4.3 (CLK)
HSYNC: IC12.11 (O), IC19.2 (I1)
LOAD: IC31.4 (C34), IC31.13 (C12), IC40.1 (CKB), IC54.1 (I), R46.1
LOAD\: IC24.8 (O)
unnamed: IC2.3 (I), R10.1, Y1.1
unnamed: IC4.7 (DIS), R3.1, R4.1
unnamed: C5.2, IC4.5 (CV)
unnamed: R4.2, R5.1, T1.1 (C)
unnamed: R5.2, R6.1, T2.1 (C)
unnamed: R6.2, R7.1, T3.1 (C)
unnamed: R7.2, R8.1, T4.1 (C)
unnamed: R8.2, R9.1, T5.1 (C)
unnamed: R9.2, T6.1 (C)
unnamed: C12.1, IC2.4 (O), IC2.5 (I), R10.2
unnamed: C6.+, IC13.5 (OUT)
unnamed: C6.-, SP1.+ (1)
unnamed: C12.2, IC2.1 (I), R17.1
unnamed: IC2.2 (O), R17.2, Y1.2
unnamed: IC2.6 (O), V1.1 (CLK)
unnamed: R18.1, V1.2 (K), V1.3 (J), V1.4 (!PRE), V1.15 (!CLR)
unnamed: R21.1, V1.10 (!PRE), V1.11 (J), V1.12 (K)
unnamed: IC11.1 (I0), IC11.2 (I1), IC11.3 (I2), R22.1
unnamed: IC11.8 (O), V2.2 (D)
unnamed: R23.1, V2.1 (!CLR), V2.4 (!PRE)
unnamed: IC12.3 (O), IC12.4 (I0)
unnamed: IC12.5 (I1), IC12.8 (O), IC12.13 (I1)
unnamed: R24.1, V3.2 (K), V3.3 (J), V3.4 (!PRE)
unnamed: IC12.6 (O), IC12.9 (I0)
unnamed: IC16.12 (O), V4.2 (D)
unnamed: R25.1, V4.1 (!CLR), V4.4 (!PRE)
unnamed: V3.15 (!CLR), V4.5 (Q)
unnamed: IC17.1 (O), IC17.5 (I0)
unnamed: IC21.1 (I0), IC21.6 (O), IC21.10 (I1)
unnamed: IC16.4 (I1), IC17.10 (O)
unnamed: IC17.13 (O), IC18.8 (I0), IC18.9 (I1)
unnamed: IC18.1 (O), IC18.6 (I1)
unnamed: IC18.4 (O), IC18.12 (I1)
unnamed: IC16.6 (O), IC19.1 (I0)
unnamed: IC18.11 (I0), IC19.3 (O), IC19.4 (I0)
unnamed: IC19.6 (O), IC20.2 (I)
unnamed: IC18.13 (O), IC20.1 (OE)
unnamed: IC18.5 (I0), IC18.10 (O)
unnamed: IC21.3 (O), IC21.5 (I1), IC23.4 (R)
unnamed: C13.1, IC21.8 (O)
unnamed: C13.2, IC2.9 (I), R29.1
unnamed: IC24.13 (I1), IC27.6 (O)
unnamed: C16.1, IC22.5 (CV)
unnamed: C17.+, IC22.6 (THR), IC22.7 (DIS), R30.2
unnamed: IC38.2 (I1), IC39.2 (O)
unnamed: C18.2, IC21.11 (O)
unnamed: C18.1, IC2.11 (I), R31.1
unnamed: IC2.10 (O), IC21.4 (I0), IC21.12 (I0)
unnamed: C20.1, IC23.5 (CV)
unnamed: C21.1, IC23.6 (THR), IC23.7 (DIS), R34.2
unnamed: C19.1, IC23.2 (TR), R32.1
unnamed: IC23.3 (Q), IC24.1 (I0)
unnamed: IC24.3 (O), IC25.2 (TR)
unnamed: C22.1, IC25.5 (CV)
unnamed: C23.+, IC25.6 (THR), IC25.7 (DIS), R35.2
unnamed: IC37.9 (I), IC38.3 (O)
unnamed: C24.1, IC26.5 (CV)
unnamed: C25.1, IC26.2 (TR), IC26.6 (THR), R36.2
unnamed: IC26.7 (DIS), R36.1, R37.2
unnamed: C26.1, IC24.6 (O)
unnamed: C26.2, IC2.13 (I), R38.1
unnamed: C27.2, IC24.11 (O)
unnamed: IC2.12 (O), IC24.5 (I1), IC24.9 (I0)
unnamed: C27.1, IC28.1 (I), R39.1
unnamed: IC29.3 (Q), IC30.2 (I1)
unnamed: C28.1, IC29.5 (CV)
unnamed: C30.2, IC30.3 (O)
unnamed: C29.1, IC29.6 (THR), IC29.7 (DIS), R40.2
unnamed: IC44.8 (QD), IC45.14 (CKA)
unnamed: MOV_POT.1 (A), R40.1
unnamed: C30.1, IC28.3 (I), R41.1
unnamed: IC31.1 (!Q1), IC32.10 (A0)
unnamed: IC31.15 (Q2), IC33.10 (A0)
unnamed: IC31.10 (Q3), IC32.13 (A2), IC33.12 (A1)
unnamed: IC28.6 (O), IC30.5 (I1)
unnamed: IC30.4 (I0), IC30.12 (I0), IC32.6 (A=B_O)
unnamed: IC28.9 (I), IC30.6 (O), IC34.2 (TR)
unnamed: IC31.9 (Q4), IC32.15 (A3), IC33.13 (A2)
unnamed: C31.2, IC34.5 (CV)
unnamed: C32.2, IC35.5 (CV)
unnamed: C33.2, IC34.6 (THR), IC34.7 (DIS), R42.1
unnamed: C34.2, IC35.6 (THR), IC35.7 (DIS), R43.1
unnamed: C35.2, IC34.3 (Q), R44.2
unnamed: C35.1, IC35.2 (TR), R45.2
unnamed: IC30.13 (I1), IC33.6 (A=B_O)
unnamed: IC30.10 (I1), IC35.3 (Q)
unnamed: IC30.11 (O), IC36.6 (I1)
unnamed: IC36.4 (O), IC36.8 (I0)
unnamed: IC36.1 (O), IC36.9 (I1)
unnamed: IC28.11 (I), IC36.10 (O)
unnamed: IC40.12 (QA), IC40.14 (CKA), IC42.7 (IA)
unnamed: IC40.9 (QB), IC42.1 (IB)
unnamed: IC40.8 (QC), IC42.2 (IC)
unnamed: IC46.12 (QA), IC46.14 (CKA), IC48.7 (IA)
unnamed: IC41.12 (QA), IC41.14 (CKA), IC43.7 (IA)
unnamed: IC41.9 (QB), IC43.1 (IB)
unnamed: IC41.8 (QC), IC43.2 (IC)
unnamed: IC41.11 (QD), IC43.6 (ID)
unnamed: IC40.11 (QD), IC41.1 (CKB), IC42.6 (ID), R47.1
unnamed: DIS1.10 (A), IC42.13 (A)
unnamed: DIS1.9 (B), IC42.12 (B)
unnamed: DIS1.8 (C), IC42.11 (C)
unnamed: DIS1.5 (D), IC42.10 (D)
unnamed: DIS1.4 (E), IC42.9 (E)
unnamed: DIS1.2 (F), IC42.15 (F)
unnamed: DIS1.3 (G), IC42.14 (G)
unnamed: DIS2.10 (A), IC43.13 (A)
unnamed: DIS2.9 (B), IC43.12 (B)
unnamed: DIS2.8 (C), IC43.11 (C)
unnamed: DIS2.5 (D), IC43.10 (D)
unnamed: DIS2.4 (E), IC43.9 (E)
unnamed: DIS2.2 (F), IC43.15 (F)
unnamed: DIS2.3 (G), IC43.14 (G)
unnamed: IC45.1 (CKB), IC45.12 (QA)
unnamed: IC46.9 (QB), IC48.1 (IB)
unnamed: IC46.8 (QC), IC48.2 (IC)
unnamed: IC50.3 (O), IC50.5 (I1)
unnamed: C39.1, IC52.6 (THR), IC52.7 (DIS), R56.1
unnamed: IC47.8 (QC), IC49.2 (IC)
unnamed: IC47.11 (QD), IC49.6 (ID)
unnamed: IC46.11 (QD), IC47.1 (CKB), IC48.6 (ID), R51.1
unnamed: DIS3.10 (A), IC48.13 (A)
unnamed: DIS3.9 (B), IC48.12 (B)
unnamed: DIS3.8 (C), IC48.11 (C)
unnamed: DIS3.5 (D), IC48.10 (D)
unnamed: DIS3.4 (E), IC48.9 (E)
unnamed: DIS3.2 (F), IC48.15 (F)
unnamed: DIS3.3 (G), IC48.14 (G)
unnamed: DIS4.10 (A), IC49.13 (A)
unnamed: DIS4.9 (B), IC49.12 (B)
unnamed: DIS4.8 (C), IC49.11 (C)
unnamed: DIS4.5 (D), IC49.10 (D)
unnamed: DIS4.4 (E), IC49.9 (E)
unnamed: DIS4.2 (F), IC49.15 (F)
unnamed: DIS4.3 (G), IC49.14 (G)
unnamed: IC38.6 (O), IC38.9 (I0)
unnamed: C37.1, IC50.6 (O)
unnamed: IC38.12 (I0), IC39.4 (O), IC39.5 (I)
unnamed: C36.1, IC38.11 (O)
unnamed: C36.2, IC39.3 (I), R54.2
unnamed: C37.2, IC39.9 (I), R55.2
unnamed: C38.2, IC52.5 (CV)
NOTE1: IC51.5 (Q1), T1.2 (B)
NOTE2: IC51.7 (Q2), T2.2 (B)
NOTE3: IC51.9 (Q3), T3.2 (B)
NOTE4: IC51.11 (Q4), T4.2 (B)
NOTE5: IC51.17 (Q1), T5.2 (B)
NOTE6: T6.2 (B)
PLAY_SOUND: IC51.1 (CLR), IC51.13 (CLR), IC52.3 (Q), R58.2
PRE_AMP: IC4.3 (Q), IC13.3 (+IN)
RESET_CLOCK: IC39.6 (O), IC46.2 (R0(1)), IC46.3 (R0(2)), IC47.2 (R0(1)), IC47.3 (R0(2)), R52.2, R53.2
SOUND_EN: IC39.11 (I), IC52.2 (TR), IC53.8 (O), R57.1
STA: IC47.12 (QA), IC47.14 (CKA), IC49.7 (IA), IC50.1 (I0)
START_PULSE: IC2.8 (O), IC21.9 (I0), IC22.2 (TR), IC24.10 (I1), IC40.2 (R0(1)), IC40.3 (R0(2)), IC41.2 (R0(1)), IC41.3 (R0(2)), R48.2, R49.2
START_TIMER: IC38.5 (I1), IC38.8 (O), IC38.13 (I1), IC44.6 (R0(1)), IC44.7 (R0(2)), IC45.2 (R0(1)), IC45.3 (R0(2))
STB: IC47.9 (QB), IC49.1 (IB), IC50.2 (I1)
VBLANK: IC16.3 (I0), IC17.3 (I1), IC17.4 (O), IC17.11 (I0)
VCC: IC2.14 (VCC), IC5.14 (VCC), IC6.5 (VCC), IC9.5 (VCC), IC11.14 (VCC), IC12.14 (VCC), IC14.5 (VCC), IC15.5 (VCC), IC16.14 (VCC), IC17.14 (VCC), IC18.14 (VCC), IC19.14 (VCC), IC20.14 (VCC), IC21.14 (VCC), IC24.14 (VCC), IC27.14 (VCC), IC28.14 (VCC), IC30.14 (VCC), IC31.5 (VCC), IC32.16 (VCC), IC33.16 (VCC), IC36.14 (VCC), IC37.14 (VCC), IC38.14 (VCC), IC39.14 (VCC), IC40.5 (VCC), IC41.5 (VCC), IC44.5 (VCC), IC45.5 (VCC), IC46.5 (VCC), IC47.5 (VCC), IC50.14 (VCC), IC51.24 (VCC), IC53.14 (VCC), IC54.14 (VCC)
VDD: IC42.16 (VDD), IC43.16 (VDD), IC48.16 (VDD), IC49.16 (VDD)
VRST: IC14.2 (R0(1)), IC14.3 (R0(2)), IC15.2 (R0(1)), IC15.3 (R0(2)), IC17.2 (I0), IC37.11 (I), IC44.1 (CKB), V4.6 (!Q)
VSS: IC42.8 (VSS), IC43.8 (VSS), IC48.8 (VSS), IC49.8 (VSS)

Notes on the sheet:
Sound Board
Horizontal Source Board
Vertical Source Board
Control Board
Note: I bridged !256H and !128H on my prototype to fix some masking issues on the player's bar. Not sure why it worked, so I'm not including it in the schematic.
Figure Board
Ambush TTL Based on schematics by David L. Heiserman from his book How to Design and Build Your Own Custom TV Games Modifications, corrections, and digitization performed by Grant Haack
1's Digit
10's Digit
Scorekeeping Board
Timer Board
Timer is set to reset after 30 seconds

Board: 2 copper layers, 143 parts (0 on the bottom side), 211 nets, no tracks yet.

## Commit log

2018-01-27 -working on the control board schematic
2018-01-27 -finished control board
2018-01-28 -finished copying my modified schematics from paper to eagle
2018-01-28 -forgot to credit Heiserman
2018-01-30 -added a feature so the paddle disappears when the game isn't started -made it so the player can't be killed by the bad guy while the bad guy is flashing
2018-01-30 -modified the good guy death circuit so it works. I'm not happy with how it works but it works so fuck it -fixed the bad guy death circuit so he can't kill the good guy while he flashes
2018-01-30 -created a scorekeeping circuit
2018-01-30 -added timing circuit -added scorekeeping circuit
2018-02-06 -optimized the sound circuitry

Notices in the files:
parts and their libraries:
SparkFun-Clocks: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
